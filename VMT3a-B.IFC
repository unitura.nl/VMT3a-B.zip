Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\MarloesAertsUnitura\HSR Groep BV\Unitura - Documenten\Producten\1. Faunavoorzieningen\1. Hout\2. VLEERMUIS TIJDELIJK\1. VMT1(a), VMT3(a)\2. Tekeningen\VMT3a-B.IFC
Time: 2026-09-22T09:57:28+00:00
Author: none
Organization: none
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3
Authorization: none

# IfcProject, Project
Description: Default Project
